Properties of the parts of a building model (IFC4)

# File
Time: 2018-09-17T14:06:01
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0
Comment: This example shows various approaches * to store dynamic data in form of table, function or documentation reference.

# IfcAirTerminalType, no part of this type: Air Terminal
PredefinedType: DIFFUSER
Air Terminal Properties - Acustic Performance [table of values]: 63: 102, 125: 99, 250: 98, 500: 98, 1000: 97, 2000: 95, 4000: 86, 8000: 81; Acustic Performance [document reference]: Acustic Performance Documentation; Acustic Performance [function]: 0.0492424242 * Math.pow(x,4) - 1.0328282828 * Math.pow(x,3) + 6.8068181818 * Math.pow(x,2) - 17.753968254 * x + 114.14285714
