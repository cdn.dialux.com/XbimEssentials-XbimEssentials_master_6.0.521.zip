Properties of the parts of a building model (IFC4X1)

# File
Description: IFC4X1
File name: OIP Revision XYZW/E.1.4 Terrain and Alignment/terrain-and-alignment-ifcalignment1x1.ifc
Time: 2017-05-24T12:27:41
Made in: IfcAlignment

# IfcSite, Terrain surface
Description: My description.; RefElevation: 0 m

# IfcAlignment (5)
In: Terrain surface
Name | Description
 | KREIS1
 | A1
 | KREIS2
 | BAUSTR
 | PROV2

# IfcGeographicElement (2)
In: Terrain surface
PredefinedType: TERRAIN
