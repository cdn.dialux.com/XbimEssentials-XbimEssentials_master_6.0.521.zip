Properties of the parts of a building model (IFC4X1)

# File
Description: IFC4X1
File name: OIP Revision XYZW/E.1.6 Bloss Curve/ex-bloss-curve-alignment1x1.ifc
Time: 2017-05-24T12:27:42
Made in: IfcAlignment

# IfcSite, Terrain surface
Description: My description.; RefElevation: 0 m

# IfcAlignment
In: Terrain surface
Description: Achse - (1)
