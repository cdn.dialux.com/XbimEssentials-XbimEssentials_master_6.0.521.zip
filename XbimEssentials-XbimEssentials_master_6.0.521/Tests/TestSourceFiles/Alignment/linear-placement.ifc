Properties of the parts of a building model (IFC4X1)

# File
Description: IFC4X1
File name: C:/dev/OpenInfraPlatform2/IFC4x1ExampleFiles/OIP Revision 1837/E.1.5 Linear Placement/linear-placement-ifc-alignment-1x1.ifc
Time: 2017-02-23T17:42:22
Made in: IfcAlignment

# IfcSite, Terrain surface
Description: My description.; RefElevation: 0 m

# IfcAlignment (5)
In: Terrain surface
Name | Description
 | KREIS1
 | A1
 | KREIS2
 | BAUSTR
 | PROV2

# IfcBuildingElementProxy, Traffic sign
In: Terrain surface
Description: Speed limit traffic sign; PredefinedType: USERDEFINED

# IfcGeographicElement (2)
In: Terrain surface
PredefinedType: TERRAIN
