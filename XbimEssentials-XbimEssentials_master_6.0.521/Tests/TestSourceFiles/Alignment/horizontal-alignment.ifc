Properties of the parts of a building model (IFC4X1)

# File
Description: IFC4X1
File name: OIP Revision XYZW/E.1.2 Horizontal Alignment/ex-horizontal-alignment-ifcalignment1x1.ifc
Time: 2017-05-24T12:27:41
Made in: IfcAlignment

# IfcSite, Terrain surface
Description: My description.; RefElevation: 0 m

# IfcAlignment (6)
In: Terrain surface
Name | Description
 | Alignment - (1)
 | Alignment - (4)
 | Alignment - (5)
 | Alignment - (7)
 | Alignment - (8)
 | Alignment - (9)
