Properties of the parts of a building model (IFC4X1)

# File
Description: IFC4X1
File name: OIP Revision XYZW/E.1.3 Terrain Surface/ex-terrain-surface-ifcalignment1x1.ifc
Time: 2017-05-24T12:27:41
Made in: IfcAlignment

# IfcSite, Terrain surface
Description: My description.; RefElevation: 0 m

# IfcAlignment
In: Terrain surface
Description: Achse_-_1

# IfcGeographicElement, Terrain
In: Terrain surface
PredefinedType: TERRAIN
