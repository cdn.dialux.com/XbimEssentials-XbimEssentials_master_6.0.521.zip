Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Validation2x3
Time: 2013-12-02T13:34:01
Written by: The EXPRESS notepad wizard
Made in: Hand Exporter 2017

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
