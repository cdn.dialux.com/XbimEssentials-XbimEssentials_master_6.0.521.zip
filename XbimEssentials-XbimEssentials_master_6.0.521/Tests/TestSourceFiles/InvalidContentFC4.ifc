Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 12345
Time: 2016-04-20T08:03:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140905_0730(x64) - Exporter 15.5.0.0 - Alternate UI 15.5.0.0

# IfcProject, 12345
LongName: IFC4 Test Project; Phase: For Information
