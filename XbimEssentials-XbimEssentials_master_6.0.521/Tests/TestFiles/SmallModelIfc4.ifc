Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 12345
Time: 2016-04-20T08:03:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140905_0730(x64) - Exporter 15.5.0.0 - Alternate UI 15.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 20 08:03:15 2016 * Host: schrodinger * Database: C:\Users\paul\AppData\Local\Temp\{F9312F7B-BFF3-4456-B24B-7D517B576CF3}\ifc * Database version: 5507 * Database creation date: Wed Apr 20 08:03:14 2016 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Apr 20 08:03:14 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 20 08:03:14 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 12345
LongName: IFC4 Test Project; Phase: For Information
