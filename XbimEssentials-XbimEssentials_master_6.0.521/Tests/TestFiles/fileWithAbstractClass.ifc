Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, SpaceBoundary1stLevelAddOnView, SpaceBoundary2ndLevelAddOnView, QuantityTakeOffAddOnView], ExchangeRequirement[Architecture]
File name: vectorworks.ifc
Time: 2015-08-06T13:48:03
Author: rob
Organization: abi
Written by: Vectorworks Architect 2016 (Build 275529) PRERELEASE (64-Bit) by Nemetschek Vectorworks, Inc.
Made in: Macintosh

# IfcProject: Vectorworks, CMP_366
LongName: CMP_366; Phase: building permit
