Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [notYetAssigned]
File name: advanced_brep.ifc
Time: 2012-05-31T11:53:44
Author: Jon
Organization: Unknown
Written by: ssiIFC - Grasshopper Plug-in by Geometry Gym Pty Ltd
Made in: ssiIFC - Grasshopper Plug-in by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: single owner history sufficient if not otherwise required by the view definition
Comment: provides the person and application creating the data set, and the time it is created
Comment: each IFC data set containing geometry has to define a geometric representation context
Comment: the attribute 'ContextType' has to be 'Model' for 3D model geometry
Comment: each IFC data set containing geometry has to define at absolute minimum length and angle
Comment: each IFC data set containing elements in a building context has to include a building
Comment: at absolute minimum (could have a site and stories as well)
Comment: geometry definition of the advanced brep
Comment: previded as the 'AdvancedBrep' representation type for the 'Body' of a building element proxy

# IfcProject, Grasshopper Project
LongName: Grasshopper Project

# IfcBuilding, Grasshopper Building
Description: GH Building
