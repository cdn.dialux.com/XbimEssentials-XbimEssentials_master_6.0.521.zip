Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Project Number
Time: 2015-09-30T13:29:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140903_1530(x64) - Exporter 15.5.0.0 - Alternate UI 15.5.0.0
Comment: entity 1 has a text with an illegal diameter character
Comment: entity 2 has numerical values with results of bugs in the producing software. 1.#INF for positive infinity -1.#INF for negative infinity -1.#IND for NaN (indeterminate)
