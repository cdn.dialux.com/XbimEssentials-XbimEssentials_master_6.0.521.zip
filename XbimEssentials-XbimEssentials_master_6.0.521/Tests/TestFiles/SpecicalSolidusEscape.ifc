Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: SpecicalSolidusEscape.ifc
Time: 2022-03-08T16:27:07
Author: Undefined
Organization: Undefined
Written by: BricsCAD BIM 22.1.07
Made in: BricsCAD BIM 22.1.07
Authorization: Undefined
Comment: Parsing examples taken from http://www.steptools.com/stds/step/IS_final_p21e3.html#table-1
Comment: The following string is valid and should end with character ascii decimal 167 or &ordm; (apostrophe is 39 + 128 = 167)
