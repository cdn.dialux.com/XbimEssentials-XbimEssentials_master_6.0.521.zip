Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: 0001
Time: 2018-07-30T16:07:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 30 16:07:51 2018 * Host: INF0937 * Database: C:\Users\AppData\Local\Temp\{DEF17C36-5B09-4EDE-986B-55E40B0F9A69}\ifc * Database version: 5507 * Database creation date: Mon Jul 30 16:07:50 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Jul 30 16:07:51 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 30 16:07:51 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - Reference: Informations sur le projet; NumberOfStoreys: 1

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm

# IfcLightFixture: TYPE 06 SANI PREFA - Spot LED, PJX_F_LUM TYPE 06 SPOT LED SANI PREFA:TYPE 06 SANI PREFA - Spot LED:140843
In: Niveau 1
Type - Classification: D5040.50 (Uniformat); Material: Plastique gris claire
Type - Pset_LightFixtureTypeCommon - Reference: TYPE 06 SANI PREFA - Spot LED
