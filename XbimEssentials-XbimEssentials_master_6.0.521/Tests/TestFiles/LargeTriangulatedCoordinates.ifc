Properties of the parts of a building model (IFC2X3)

# File
Time: 2019-08-13T10:09:00
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, Site
RefElevation: 0 m
Pset_SiteCommon - BuildableArea: 0 m2
Site - Site Name: Site; Building Height Limit: 0 m

# IfcBuilding, Bldg 1
Description: Bentley Systems Pty Ltd; LongName: Branch at Sydney; ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - YearOfConstruction: 2013
Postal Address - Postal | Address Line 1: Level 6; Postal | Address Line 2: 6 Riverside Quay; Postal | City: Southbank; Postal | Region: Victoria; Postal | Code: 3006; Postal | Country: Australia
Identification - ID | Number: 101; ID | Name (Alternate): Branch at Sydney; ID | Description: Bentley Systems Pty Ltd
Building Parameters - Building Name: Bldg 1; Year Constructed: 2013
BaseQuantities - AbsoluteElevation: 0 m

# IfcBuildingStorey, OFFICE FLOOR 2
In: Bldg 1
Description: Second Floor Level; Elevation: 8.7 m
Pset_BuildingStoreyCommon - GrossAreaPlanned: 0 m2; NetAreaPlanned: 0 m2
Structural Floor Parameters - Column Splice Floor: no
Floor Parameters - Floor Name: OFFICE FLOOR 2; Elevation | Finished Floor: 8.7; Description: Second Floor Level; Length (Approx.): 6 m; Width (Approx.): 4 m; Typical Floor: no; Typical Floor Height: 0 m; Typical Floor Base Elevation: 0 m; ACS Rotation Angle: 0.00000000; Annotate: yes
Floor - Area (Gross): 0 m2; Area (Net): 0 m2; Occupancy Type: Office; Owner: Bentley Systems Inc
BaseQuantities - AbsoluteElevation: 8.7 m

# IfcBuildingElementProxy
In: OFFICE FLOOR 2
Description: 0 , SMCSWLWC-SYC-RTF-RD-D-PLAN-3D MASTER MODEL.dgn, Default-3D:532326
