Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedReferenceView]
File name: linear-placement-of-signal.ifc
Time: 2023-07-11T10:16:10
Author: redacted
Organization: redacted
Written by: redacted
Made in: redacted
Authorization: redacted

# IfcProject, Stationing
Description: Default Project Description

# IfcAlignment: Railway track alignment, Track alignment
In: Default Railway Name
PredefinedType: USERDEFINED

# IfcAlignmentCant, C1
RailHeadDistance: 1.435 m

# IfcReferent (23)
In: Default Railway Name
Name | PredefinedType | Station (m)
StaStation | STATION | -153.1
End | REFERENCEMARKER | 876.272
Referent_001 | REFERENCEMARKER | -150
Referent_002 | REFERENCEMARKER | -100
Referent_003 | REFERENCEMARKER | -50
Referent_004 | REFERENCEMARKER | 0
Referent_005 | REFERENCEMARKER | 50
Referent_006 | REFERENCEMARKER | 100
Referent_007 | REFERENCEMARKER | 150
Referent_008 | REFERENCEMARKER | 200
Referent_009 | REFERENCEMARKER | 250
Referent_010 | REFERENCEMARKER | 300
Referent_011 | REFERENCEMARKER | 350
Referent_012 | REFERENCEMARKER | 400
Referent_013 | REFERENCEMARKER | 450
Referent_014 | REFERENCEMARKER | 500
Referent_015 | REFERENCEMARKER | 550
Referent_016 | REFERENCEMARKER | 600
Referent_017 | REFERENCEMARKER | 650
Referent_018 | REFERENCEMARKER | 700
Referent_019 | REFERENCEMARKER | 750
Referent_020 | REFERENCEMARKER | 800
Referent_021 | REFERENCEMARKER | 850

# IfcSignal: Default Signal Type (2)
In: Default Railway Name
Type - PredefinedType: VISUAL
Name
Route Indicator_01
Route Indicator_02
