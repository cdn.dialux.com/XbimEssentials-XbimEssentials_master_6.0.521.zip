Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: beam-curved-i-shape-tessellated.ifc
Time: 2014-06-09T14:06:08
Author: redacted
Organization: redacted
Written by: redacted
Made in: redacted
Comment: file name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: set the context of the IFC4 exchange file
Comment: name, units and geometric representation context
Comment: note: IfcOwnerHistory is not in scope of the IFC4 reference view
Comment: optionally define recurring instances, such as zero point and main directions
Comment: those can be referenced multiple times reducing file sizes
Comment: set the representation context for 3D body, and 2D axis representation
Comment: north direction is set to positive y-axis, no geo-spatial coordinates are provided
Comment: set the default units - and the units used for geometric representations
Comment: defines the default building (as required as the minimum spatial element)
Comment: defines the beam as a model element using tessellated geometry
Comment: beam is placed at 0.,0.,0. within the building coordinate system
Comment: geometric representation of the beam is given as tessellated geometry
Comment: a single material is provided for the beam
Comment: the geometric representation of the beam is provided as a triangulated face set
Comment: the meshing depends on the creating software system
Comment: note: this meshing is rather fine, in most cases a coarser meshing is advisable

# IfcProject, Grasshopper Project
LongName: Grasshopper Project

# IfcBuilding, B1
Description: building used for the unit test case; LongName: Default building

# IfcBeam, Beam 2
In: B1
Description: beam 2 used for the unit test case; Material: S355JR
