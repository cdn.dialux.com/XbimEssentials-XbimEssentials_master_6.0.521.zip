Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [DesignTransferView_V1]
File name: curve-parameters-in-degrees.ifc
Time: 2017-06-28T23:09:53
Author: redacted
Organization: redacted
Written by: redacted
Made in: redacted
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: defines the default building (as required as the minimum spatial element)
Comment: These profile curves are intentionally expressed in a more complicated manner than possible to test parameterization
Comment: general entities required for all IFC sets, defining the context for the exchange
Comment: Example data for CurveParametersDegrees

# IfcColumn: CurviLinearTriangle
In: IfcBuilding
Type - PredefinedType: COLUMN; Material: Steel

# IfcColumn: PartialEllipse
In: IfcBuilding
Type - PredefinedType: COLUMN; Material: Steel

# IfcColumn: SemiCircle
In: IfcBuilding
Type - PredefinedType: COLUMN; Material: Steel
