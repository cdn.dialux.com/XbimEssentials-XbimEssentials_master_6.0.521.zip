Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [notYetAssigned]
File name: polygonal-face-tessellation.ifc
Time: 2016-05-26T17:38:29
Author: redacted
Organization: redacted
Written by: redacted
Made in: redacted
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: polygonal face set geometry representation
Comment: assigned as shape representation to a proxy
Comment: definition of the minimal building structure, units, owner history

# IfcBuilding, Grasshopper Building
Description: GH Building; LongName: GH Building; ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
