Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [ReferenceView_V1]
File name: beam-straight-i-shape-tessellated.ifc
Time: 2016-02-04T08:11:04
Author: redacted
Organization: redacted
Written by: redacted
Made in: redacted
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: general entities required for all IFC data sets, defining the context for the exchange
Comment: defines the default building (as required as the minimum spatial element)
Comment: the meshing depends on the creating software system

# IfcBeam, ExampleBeamName
In: IfcBuilding
Description: ExampleBeamDescription
