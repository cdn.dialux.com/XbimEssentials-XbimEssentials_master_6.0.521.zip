Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: GeoReference
File name: geographic-referencing-utm.ifc
Time: 2017-07-10T15:03:00
Author: redacted
Organization: redacted
Written by: redacted
Authorization: none
Comment: description
Comment: implementation level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation
Comment: Geographic reference
Comment: BuildingElementProxy
Comment: Tesselated geometry
Comment: (2,3,4),(4,5,2),
Comment: BuildingStorey
Comment: Person, Org, App, Project
Comment: Site
Comment: Building
Comment: Placement
Comment: Units

# IfcSite, Site
RefLatitude: 49, 5, 43, 983700; RefLongitude: 8, 26, 1, 247300; RefElevation: 113.7 mm

# IfcBuildingStorey, Storey 1
In: Building
Elevation: -1.6 mm
