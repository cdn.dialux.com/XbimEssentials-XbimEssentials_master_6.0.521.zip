Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [notYetAssigned], Option [Filter: VisibleElements]
File name: grid-placement.ifc
Time: 2013-07-13T10:17:34
Author: redacted
Organization: redacted
Written by: redacted
Made in: redacted
Authorization: redacted
Comment: Owner history as dummy information, maybe omitted
Comment: Global unit definitions
Comment: Defining reusable commonly used directions and points
Comment: Defining project and representation contexts
Comment: Defining site, building and first story
Comment: Defining the grid axes geometry
Comment: Defining the grid with 5 u-axes and 5 v-axes
Comment: Column with grid placement
Comment: Beam with local placement
Comment: assignment to spatial structure

# IfcSite, Default Site
RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0

# IfcBuildingStorey, Ground Floor
In: Default Building
Elevation: 0 mm

# IfcBeam (10)
In: Ground Floor
Material: Structural Concrete

# IfcColumn (25)
In: Ground Floor
Material: Structural Concrete
