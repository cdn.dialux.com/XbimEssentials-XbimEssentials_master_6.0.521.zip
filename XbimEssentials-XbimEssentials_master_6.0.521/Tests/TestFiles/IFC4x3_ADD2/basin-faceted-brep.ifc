Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [DesignTransferView_V1]
File name: basin-faceted-brep.ifc
Time: 2016-02-04T08:47:55
Author: redacted
Organization: redacted
Written by: redacted
Made in: redacted
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: general entities required for all IFC data sets, defining the context for the exchange
Comment: defines the default building (as required as the minimum spatial element)

# IfcSanitaryTerminal: Wash Hand Basin
In: IfcBuilding
Type - PredefinedType: WASHHANDBASIN; Material: Ceramic
