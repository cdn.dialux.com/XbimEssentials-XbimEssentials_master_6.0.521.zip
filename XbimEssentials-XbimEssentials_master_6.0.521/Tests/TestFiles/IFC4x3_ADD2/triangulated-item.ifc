Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [notYetAssigned], Comment [manual creation of example file]
File name: triangulated-item.ifc
Time: 2012-07-04T18:00:00
Author: redacted
Organization: redacted
Written by: redacted
Made in: redacted
Authorization: reference file created for the IFC4 specification
Comment: NOTE a valid model view name has to be asserted, replacing 'notYetAssigned'
Comment: NOTE standard header information according to ISO 10303-21
Comment: general entities required for all IFC data sets, defining the context for the exchange
Comment: single owner history sufficient if not otherwise required by the view definition
Comment: provides the person and application creating the data set, and the time it is created
Comment: each IFC data set containing geometry has to define a geometric representation context
Comment: the attribute 'ContextType' has to be 'Model' for 3D model geometry
Comment: the attribute 'ContextIdentifier' has to be 'Body' for the main 3D shape representation
Comment: each IFC data set containing geometry has to define at absolute minimum length and angle
Comment: here length is milli metre as SI unit, and plane angle is 'degree' as non SI unit
Comment: each IFC data set containing elements in a building context has to include a building
Comment: at absolute minimum (could have a site and stories as well)
Comment: if the building is the uppermost spatial structure element it defines the absolut position --
Comment: no rotation - z and x axes set to '$' are therefore identical to "world coordinate system" --
Comment: if the building is the uppermost spatial structure element it is assigned to the project
Comment: shared coordinates - it is permissable to share common instances to reduce file size
Comment: proxy element with tessellated shape representation, assigned to the building
Comment: proxy element placement relative to the building
Comment: set local placement to 1 meter on x-axis, and 0 on y, and 0 on z axes
Comment: no rotation - z and x axes set to '$' are therefore identical to those of building
Comment: proxy element shape representation
Comment: a single shape representation of type 'Tessellation' is included
Comment: tessellated surface representation by triangulation
Comment: cube, 1m width, 1m depth, 2m height
Comment: proxy element assigned to the building

# IfcBuildingElementProxy, P-1
In: Test Building
Description: sample proxy
