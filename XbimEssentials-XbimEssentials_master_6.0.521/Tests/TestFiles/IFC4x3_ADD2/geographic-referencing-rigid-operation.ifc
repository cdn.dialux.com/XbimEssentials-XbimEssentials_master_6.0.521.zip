Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition[Alignment-basedReferenceView]
File name: geographic-referencing-rigid-operation.ifc
Time: 2022-11-16T10:37:00
Written by: redacted
Made in: redacted
Comment: The basis definitions of an IfcProject and IfcGeometricRepresentationContext
Comment: Georeferencing data of an IFC dataset in a Geographic CRS. The site with this context lies at the Bell tower on the island of Lake Bled in Slovenia.
Comment: IfcSite definition
Comment: IfcSite's placement is the top-most placement and uses the same IfcAxis2Placement as IfcGeometricRepresentationContext does
Comment: Relationship between Project and Site
Comment: Definition of a Footprint
Comment: Relationship: Footprint in Site
Comment: Placement of the Footprint, relative to that of IfcSite. The way it is modelled, there is no offset and no rotation.
Comment: Representation of the Footprint: a polyline with six points
Comment: Definition of a Cube
Comment: Relationship: Cube in Site
Comment: Placement of the cube, relative to that of IfcSite.
Comment: Set local placement to 1 meter on x-axis, and 0 on y and z axes, no rotation. z and x axes are set to '$' and therefore identical to those of Site
Comment: Representation of the Cube: a single swept solid shape
Comment: based on a profile (or cross section) of 3m by 4m being extruded by 1.5m
Comment: extrusion body is placed centric with no rotation inside the object coordinate placement
Comment: extrusion position z = default = (0.,0.,1.), x = default = (1.,0.,0.)
Comment: the default position, i.e. no re-positioning of the results, hence the position is NIL
Comment: the extrusion is perpendicular to the profile - i.e. along the positive z-axis
