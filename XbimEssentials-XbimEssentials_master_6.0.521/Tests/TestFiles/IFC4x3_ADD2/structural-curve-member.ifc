Properties of the parts of a building model (IFC4X3_ADD2)

# File
File name: structural-curve-member.ifc
Time: 2023-07-18
Written by: redacted
Made in: redacted
Comment: Owner history user and application
Comment: Units
Comment: The project
Comment: Owner history referenced by all objects
Comment: Project coordinate system
Comment: Structural analysis model
Comment: Analysis model is declared on project; this distinguishes top-level analysis models from potential aggregated sub-models
Comment: The structural member for the left column (object)
Comment: The structural node underneath the left column
Comment: assignment of connections and members to the analysis model
Comment: fixed restraint at node underneath left column
Comment: The structural node above the left column
Comment: The structural member for the left column (representation)
Comment: The structural member for the right column (object)
Comment: The structural node underneath the right column
Comment: The structural node connecting the right column to the beam
Comment: The structural member for the right column (representation)
Comment: The structural member for the beam
Comment: single load case
Comment: linear load along left half of beam
Comment: Material profile set associated with each structural member
Comment: Material and properties
Comment: Profile and properties
Comment: The result group indicating reactions for the load case
Comment: The node below the left column has no displacement (it has fixed boundary condition so it shouldn't)
Comment: Each reaction is assigned to the result group.
Comment: The node below the left column has a reaction with force upwards and to the right and moment counter-clockwise as facing +Y
Comment: The node above the left column has a displacement to the left (sway)
Comment: The node below the right column has no displacement (it has a fixed boundary condition so it shouldn't)
Comment: The node below the right column has a reaction with force updwards and to the left and moment clockwise as facing +Y
Comment: The node above the right column has a displacement to the left (sway)
Comment: The member for the left column has end reactions for which shear and moment diagrams may be derived
Comment: The member for the right column has end reactions for which shear and moment diagrams may be derived
Comment: The member for the beam has end reactions for which shear and moment diagrams may be derived

# IfcStructuralCurveAction, Structural Curve Action #1
GlobalOrLocal: GLOBAL_COORDS; DestabilizingLoad: no; PredefinedType: LINEAR; Group: Structural Load Case #1

# IfcStructuralCurveMember (3)
PredefinedType: RIGID_JOINED_MEMBER; Material: ASTM A36; Group: Structural Analysis #1
Name
Curve Member #1
Curve Member #2
Curve Member #3

# IfcStructuralCurveReaction (3)
GlobalOrLocal: GLOBAL_COORDS; PredefinedType: DISCRETE; Group: FIRST_ORDER_THEORY yes

# IfcStructuralLoadCase, Structural Load Case #1
PredefinedType: LOAD_CASE; Coefficient: 1; SelfWeightCoefficients: 0, 0, 0

# IfcStructuralPointConnection (4)
Group: Structural Analysis #1
Name
Point Connection #1
Point Connection #2
Point Connection #3
Point Connection #4

# IfcStructuralPointReaction (6)
GlobalOrLocal: GLOBAL_COORDS; Group: FIRST_ORDER_THEORY yes

# IfcStructuralResultGroup
TheoryType: FIRST_ORDER_THEORY; IsLinear: yes

# Material: ASTM A36
Pset_MaterialCommon - MassDensity: 0.284011 pound/cubic inch
Pset_MaterialMechanical - YoungModulus: 29 pound/in2; ShearModulus: 11.2 pound/in2
