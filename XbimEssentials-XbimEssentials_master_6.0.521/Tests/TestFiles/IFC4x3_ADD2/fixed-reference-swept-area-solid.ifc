Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: fixed-reference-swept-area-solid.ifc
Time: 2021-05-31T10:24:22
Written by: redacted

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 m
