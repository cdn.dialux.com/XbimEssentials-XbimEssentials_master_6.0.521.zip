Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: column-straight-rectangle-tessellation.ifc
Time: 2014-07-08T19:20:14
Author: redacted
Written by: redacted
Made in: redacted
Comment: set the default units - and the units used for geometric representations
Comment: here imperial units (inch) are used
Comment: set the context of the IFC4 exchange file
Comment: name, units and geometric representation context
Comment: note: IfcOwnerHistory is not in scope of the IFC4 reference view
Comment: set the representation context for 3D body, and 2D axis representation
Comment: no north direction and no geo-spatial coordinates are provided
Comment: defines the default site (as required as the minimum spatial element)
Comment: defines the column with rectangular cross section as a model element
Comment: using tessellated geometry
Comment: the triangulated tessellation also includes the normals per face and vertex
Comment: in this case, the vertex list and the normal list are corresponding lists,
Comment: hence no separate normal index has to be provided at IfcTriangulatedFaceSet
Comment: it generated longer lists, but is in line with many graphic APIs using a single buffer list

# IfcColumn, Column #1
In: Site #1
PredefinedType: COLUMN
