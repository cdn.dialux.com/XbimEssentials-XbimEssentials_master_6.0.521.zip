Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [notYetAssigned]
Time: 2014-12-09T00:27:54
Author: Jon
Organization: Unknown
Written by: ggIFC - Exporter by Geometry Gym Pty Ltd
Made in: ggIFC - Exporter by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, IfcProject
LongName: IfcProject
