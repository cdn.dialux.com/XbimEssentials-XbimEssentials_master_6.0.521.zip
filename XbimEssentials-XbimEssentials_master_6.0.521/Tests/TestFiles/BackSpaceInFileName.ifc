Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement[Architecture]
File name: /Volumes/CAD/Projekte/Name Wort/PROJEKT/03_Plane/05/Name.ifc
Time: 2018-03-19T12:35:37
Author: Name
Organization: App, Inc.
Written by: App (Build 401138) (64-Bit) by App, Inc.
Made in: Macintosh

# IfcProject: App, Island
LongName: Code; Phase: Code2
