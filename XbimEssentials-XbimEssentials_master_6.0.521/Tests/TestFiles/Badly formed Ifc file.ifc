Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Visible elements;Keep GUIDs;All Domain;All elements;All struct.;scale:100.000000;CSG:Extruded/revolved;Junction:Extruded/revolved;Comp. slab:Extruded;Building element parts]
File name: F:\Dropbox\00 - ndBIM_Coordenação\01 - Parcerias Comerciais\YellowBox\2015-09-24\Edalco_Fabiano Alves\IFC\ARQ.ifc
Time: 2015-09-25T10:25:06
Author: MCAA
Organization: Building Designer Office
Written by: PreProc - EDM 5.0
Made in: IFC file generated by Graphisoft ArchiCAD-64 17.0.0 INT FULL Windows version (IFC2x3 add-on version: 6004 INT FULL).
Authorization: MCAA

# IfcBuildingStorey, Кровля
Elevation: 3350
