Properties of the parts of a building model (IFC4X3_ADD1)

# File
Description: ViewDefinition [Alignment-basedReferenceView]
File name: SectionedSolidHorizontal-1.ifc
Time: 2021-05-31T10:35:59
Written by: ACCA_IFC.dll Version 500
Comment: This file has been manually udated by GP (CSTB)

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 m
