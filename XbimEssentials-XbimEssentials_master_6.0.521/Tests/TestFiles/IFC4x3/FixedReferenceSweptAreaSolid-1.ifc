Properties of the parts of a building model (IFC4X3)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: FixedReferenceSweptAreaSolid-1.ifc
Time: 2021-05-31T10:24:22
Written by: ACCA_IFC.dll Version 500

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 m
