Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2016-05-18T15:48:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI

# IfcSanitaryTerminalType, no part of this type: S6966MY - Contour 21 Close coupled Doc M pack LH - Stainless
PredefinedType: TOILETPAN
Constraints - Default Elevation: 0
General - Author: Ideal Standard (UK) Ltd; BIMObjectName: ASH_ArmitageShanks_DocMPacks_CCLeftHandPack_S6966; ManufacturerURL: www.idealspec.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/njx3wzt3; NBSDescription: Accessible WC Doc M equipment packages; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/407; NBSTypeID: n/a; ProductInformation: www.idealspec.co.uk/datasheets/A6966MY; Revision: n/a; Uniclass2: Pr_40_20_60_02; Version: 3
Green Building Properties - BREEAMApproved: yes; ECA: yes; WaterEfficientProduct: yes; WRAS: yes
Identity Data - Assembly Code: C1030200; Assembly Description: Bath & Toilet Accessories; Description: Doc M Contour 21 close coupled left hand corner pack; Manufacturer: Productinfo@thebluebook.co.uk; Model: S6966MY; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; Type Comments: n/a; Type Name: S6966MY - Contour 21 Close coupled Doc M pack LH - Stainless; URL: www.idealspec.co.uk
Materials and Finishes - GrabRailMaterial: ASH_ArmitageShanks_GrabBars_Contour21_StainlessMY_render
Mechanical - CWFU: 0; HWFU: 0; WFU: 0
Other - AccessibilityPerformance: DDA compliant, building regs part-m; Accessories: www.idealspec.co.uk; AreaMeasurement: n/a; AreaUnits: millimeters; AssetType: Fixed; Brand: Armitage Shanks; Category: n/a; CodePerformance: Doc m, dda; ConnectionType: Plumbing; Constituents: n/a; CreatedOn: 2015-04-22; CurrencyUnit: n/a; DistributedBy: n/a; DurationUnit: year; ExpectedLife: Varies; Family Name: ASH_ArmitageShanks_DocMPacks_CCLeftHandPack_S6966; Features: Doc M Contour 21 close coupled left hand corner pack, WC pan, water saving delay fill cistern with spatula lever, grab rails, hinged support rail with toilet roll holder, seat no cover with retaining buffers, copper tails on TMV3 mixer tap; Finish: Stainless rails, white china, chrome tap; Grade: n/a; GrossWeight: n/a; Help: www.idealspec.co.uk/contact-us.html; InstallationInstructions: www.idealspec.co.uk/resources.html; LinearUnits: millimeters; ModelNumber: S6966MY; ModelReference: Doc M Contour 21 close coupled left hand corner pack; Name: DocMPacks_Contour21-CloseCoupled-LH-S6966_ArmitageShanks; NettWeight: 70 Kg; NominalHeight: 1400; Phone: 01543 490 253; ReplacementCost: n/a; Shape: n/a; Size: 2200 x 1500 x 1400 mm; Space: Internal; SustainabilityPerformance: n/a; VolumeUnits: Litres; WarrantyDescription: Manufacturers warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: Varies per component; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: Productinfo@thebluebook.co.uk
Pset_SanitaryTerminalTypeToiletPan - ToiletType: Other; ToiletPanType: WashDown; PanMounting: Other; SpilloverLevel: 450; NominalLength: 2200; NominalWidth: 1500; NominalDepth: 1450
